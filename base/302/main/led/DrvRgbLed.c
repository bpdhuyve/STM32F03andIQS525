//================================================================================================//
// M O D U L E   H E A D E R
//------------------------------------------------------------------------------------------------//
// Implementation of the common part of the RGB LED driver
//
// Copyright (c), PsiControl Mechatronics NV, All rights reserved.
//================================================================================================//
#define LED__RGBLED_C
//================================================================================================//



//================================================================================================//
// V E R I F Y    C O N F I G U R A T I O N
//------------------------------------------------------------------------------------------------//
#include "AppConfig.h"
//------------------------------------------------------------------------------------------------//
// @brief  Defines the log level of the module
#ifndef LED__RGBLED_LOG_LEVEL
	#define CORELOG_LEVEL               LOG_LEVEL_NONE
#else
	#define CORELOG_LEVEL               LED__RGBLED_LOG_LEVEL
#endif
//------------------------------------------------------------------------------------------------//
// @brief  Defines if the intensity has to be handled as quadratic (1) or linear (0)
#ifndef USE_QUADRATIC_CURVE
    #define USE_QUADRATIC_CURVE         1
#endif
//================================================================================================//



//================================================================================================//
// I N C L U D E S
//------------------------------------------------------------------------------------------------//
#include "Core.h"

// DRV
#include "led\DrvRgbLed.h"
//================================================================================================//



//================================================================================================//
// L O C A L   D E F I N I T I O N S   A N D   M A C R O S
//------------------------------------------------------------------------------------------------//
//================================================================================================//



//================================================================================================//
// L O C A L   T Y P E D E F S
//------------------------------------------------------------------------------------------------//
//================================================================================================//



//================================================================================================//
// L O C A L   F U N C T I O N   P R O T O T Y P E S
//------------------------------------------------------------------------------------------------//
//================================================================================================//



//================================================================================================//
// L O C A L   V A R I A B L E S
//------------------------------------------------------------------------------------------------//
//================================================================================================//



//================================================================================================//
// E X P O R T E D   V A R I A B L E S
//------------------------------------------------------------------------------------------------//
//================================================================================================//



//================================================================================================//
// L O C A L   F U N C T I O N S
//------------------------------------------------------------------------------------------------//
//================================================================================================//



//================================================================================================//
// E X P O R T E D   F U N C T I O N S
//------------------------------------------------------------------------------------------------//
void DrvRgbLed_Init(void)
{
    // nothing to do
}
//------------------------------------------------------------------------------------------------//
BOOL DrvRgbLed_SetRgb(RGBLED_HNDL led_hndl, U8 red, U8 green, U8 blue)
{
    if((led_hndl != NULL) && (led_hndl->hook_list_ptr != NULL) && (led_hndl->hook_list_ptr->set_level_hook != NULL))
    {
        return led_hndl->hook_list_ptr->set_level_hook(led_hndl->led_id, red, green, blue);
    }
    return FALSE;
}
//------------------------------------------------------------------------------------------------//
BOOL DrvRgbLed_SetColor(RGBLED_HNDL led_hndl, RGBLED_COLOR new_color, RGBLED_INTENSITY new_intensity)
{
    U16 intensities[4];
    
    // check color, max 0x3F
    if(new_color > 0x3F)
    {
        return FALSE;
    }
    
    // calculated basic levels based on intensity
    intensities[3] = (U16)new_intensity;
    #if ((USE_QUADRATIC_CURVE) == 1)
    {
        intensities[3] *= ((U16)new_intensity + 1);
        intensities[3] >>= 8;
    }
    #endif
    intensities[2] = (intensities[3] + 1) >> 1;
    intensities[1] = (intensities[2] + 1) >> 1;
    intensities[0] = 0;
    
    // try to apply
    if(DrvRgbLed_SetRgb(led_hndl,
                        (U8)(intensities[(new_color >> 4) & 0x03]),
                        (U8)(intensities[(new_color >> 2) & 0x03]),
                        (U8)(intensities[(new_color >> 0) & 0x03])))
    {
        // store settings
        led_hndl->led_color     = new_color;
        led_hndl->led_intensity = new_intensity;
        
        return TRUE;
    }
    
    return FALSE;
}
//------------------------------------------------------------------------------------------------//
BOOL DrvRgbLed_UpdateColor(RGBLED_HNDL led_hndl, RGBLED_COLOR new_color)
{
    if(led_hndl != NULL)
    {
        return DrvRgbLed_SetColor(led_hndl, new_color, led_hndl->led_intensity);
    }
    return FALSE;
}
//------------------------------------------------------------------------------------------------//
BOOL DrvRgbLed_UpdateIntensity(RGBLED_HNDL led_hndl, RGBLED_INTENSITY new_intensity)
{
    if(led_hndl != NULL)
    {
        return DrvRgbLed_SetColor(led_hndl, led_hndl->led_color, new_intensity);
    }
    return FALSE;
}
//================================================================================================//
