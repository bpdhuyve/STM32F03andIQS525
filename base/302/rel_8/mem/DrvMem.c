//================================================================================================//
// M O D U L E   H E A D E R
//------------------------------------------------------------------------------------------------//
// Implementation of the common part of the memory driver
//
// Copyright (c), PsiControl Mechatronics NV, All rights reserved.
//================================================================================================//
#define MEM__DRVMEM_C
//================================================================================================//



//================================================================================================//
// V E R I F Y    C O N F I G U R A T I O N
//------------------------------------------------------------------------------------------------//
#include "AppConfig.h"
//------------------------------------------------------------------------------------------------//
// @brief  Defines the log level of the module
#ifndef MEM__DRVMEM_LOG_LEVEL
	#define CORELOG_LEVEL               LOG_LEVEL_NONE
#else
	#define CORELOG_LEVEL               MEM__DRVMEM_LOG_LEVEL
#endif
//================================================================================================//



//================================================================================================//
// I N C L U D E S
//------------------------------------------------------------------------------------------------//
#include "Core.h"

//DRV include section
#include "mem\DrvMem.h"
//================================================================================================//



//================================================================================================//
// L O C A L   D E F I N I T I O N S   A N D   M A C R O S
//------------------------------------------------------------------------------------------------//
//================================================================================================//



//================================================================================================//
// L O C A L   T Y P E D E F S
//------------------------------------------------------------------------------------------------//
//================================================================================================//



//================================================================================================//
// L O C A L   F U N C T I O N   P R O T O T Y P E S
//------------------------------------------------------------------------------------------------//
//================================================================================================//



//================================================================================================//
// L O C A L   V A R I A B L E S
//------------------------------------------------------------------------------------------------//
//================================================================================================//



//================================================================================================//
// E X P O R T E D   V A R I A B L E S
//------------------------------------------------------------------------------------------------//
//================================================================================================//



//================================================================================================//
// L O C A L   F U N C T I O N S
//------------------------------------------------------------------------------------------------//
//================================================================================================//


//================================================================================================//
// E X P O R T E D   F U N C T I O N S
//------------------------------------------------------------------------------------------------//
void DrvMem_Init(void)
{
}
//------------------------------------------------------------------------------------------------//
BOOL DrvMem_Clear(MEM_HNDL mem_hndl)
{
    if((mem_hndl != NULL) && (mem_hndl->hook_list_ptr != NULL) && (mem_hndl->hook_list_ptr->mem_clear_hook != NULL))
    {
        return mem_hndl->hook_list_ptr->mem_clear_hook(mem_hndl->mem_id);
    }
    LOG_WRN("MEM clear function is NULL");
    return FALSE;
}
//------------------------------------------------------------------------------------------------//
BOOL DrvMem_ReadData(MEM_HNDL mem_hndl, U32 address, U8* data_ptr, U16 length)
{
    if((mem_hndl != NULL) && (mem_hndl->hook_list_ptr != NULL) && (mem_hndl->hook_list_ptr->mem_read_hook != NULL))
    {
        return mem_hndl->hook_list_ptr->mem_read_hook(mem_hndl->mem_id, address, data_ptr, length);
    }
    LOG_WRN("MEM read function is NULL");
    return FALSE;
}
//------------------------------------------------------------------------------------------------//
BOOL DrvMem_WriteData(MEM_HNDL mem_hndl, U32 address, U8* data_ptr, U16 length)
{
    if((mem_hndl != NULL) && (mem_hndl->hook_list_ptr != NULL) && (mem_hndl->hook_list_ptr->mem_write_hook != NULL))
    {
        return mem_hndl->hook_list_ptr->mem_write_hook(mem_hndl->mem_id, address, data_ptr, length);
    }
    LOG_WRN("MEM write function is NULL");
    return FALSE;
}
//------------------------------------------------------------------------------------------------//
BOOL DrvMem_VerifyData(MEM_HNDL mem_hndl, U32 address, U8* data_ptr, U16 length)
{
    if((mem_hndl != NULL) && (mem_hndl->hook_list_ptr != NULL) && (mem_hndl->hook_list_ptr->mem_verify_hook != NULL))
    {
        return mem_hndl->hook_list_ptr->mem_verify_hook(mem_hndl->mem_id, address, data_ptr, length);
    }
    LOG_WRN("MEM verify function is NULL");
    return FALSE;
}
//------------------------------------------------------------------------------------------------//
BOOL DrvMem_Flush(MEM_HNDL mem_hndl)
{
    if((mem_hndl != NULL) && (mem_hndl->hook_list_ptr != NULL) && (mem_hndl->hook_list_ptr->mem_flush_hook != NULL))
    {
        return mem_hndl->hook_list_ptr->mem_flush_hook(mem_hndl->mem_id);
    }
    LOG_WRN("MEM flush function is NULL");
    return FALSE;
}
//================================================================================================//
