# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030C6 ST STM32F030C6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: IAR_ARM_CM3
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: src; ..\..\..\..\base\000\rel_9; ..\..\..\..\base\017\rel_7; ..\..\..\..\base\302\rel_9; ..\..\..\..\base\303\rel_11; ..\..\..\..\base\304\rel_9; ..\..\..\..\base\305\main; ..\..\..\..\app\2013\13020\rel_4; ..\..\..\..\app\2015\15029\main\src\ReaderLib; ..\..\..\..\app\2015\15029\main\src\ReaderLib\comps; ..\..\..\..\app\2015\15029\main\src\ReaderLib\intfs; ..\..\..\..\app\2015\15029\main\src\ReaderLib\types; ..\..\..\..\app\2015\15029\main\src\ReaderLib\comps\comps\phbalReg\src\Stub
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: src
  OBJCOPY.OOCOutputFile: output.hex
  ILINK.IlinkOutputFile: link.out
  ILINK.IlinkIcfFile: linker.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  group 1. APP
    src/: AppConfig.h AppLeds.c AppLeds.h AppLedStrip.c AppLedStrip.h AppLogic.c AppLogic.h AppMain.c AppMain.h AppTest.c AppTest.h AppTouch.c AppTouch.h AppVersion.h IQS5xx.h IQS5xx_Init.h
  group 2. TESTLIB
    ../../../2013/13020/rel_4/: TestLibGpio.c TestLibGpio.h TestLibVersion.h
  group 5. COMM
    ../../../../base/305/main/dmx/: CommDllDmx.c CommDllDmx.h
  group 7. CORE
    ../../../../base/303/rel_11/: Core.c Core.h CoreBuffer.c CoreBuffer.h CoreConvert.c CoreConvert.h CoreLog.c CoreLog.h CoreQ.c CoreQ.h CoreString.c CoreString.h CoreTask.c CoreTask.h CoreTerm.c CoreTerm.h CoreVersion.h
  group 8. DRV/gpio
    ../../../../base/302/rel_9/gpio/: DrvGpio.c DrvGpio.h DrvGpioSys.c DrvGpioSys.h
  group 8. DRV/i2c
    ../../../../base/302/rel_9/i2c/: DrvI2cMasterChannel.c DrvI2cMasterChannel.h DrvI2cMasterChannelBitBang.c DrvI2cMasterChannelBitBang.h DrvI2cMasterChannelSysInt.c DrvI2cMasterChannelSysInt.h DrvI2cMasterDevice.c DrvI2cMasterDevice.h
  group 8. DRV/sci
    ../../../../base/302/rel_9/sci/: DrvSciChannel.c DrvSciChannel.h DrvSciChannelSysInt.c DrvSciChannelSysInt.h DrvSciQRxTpl.h DrvSciQTxTpl.h
  group 8. DRV/timer
    ../../../../base/302/rel_9/timer/: DrvPwm.c DrvPwm.h DrvPwmSys.c DrvPwmSys.h
  group 8. DRV/version
    ../../../../base/302/rel_9/: DrvVersion.h
  group 9. (I)SYS/core
    ../../../../base/000/rel_9/core/: ISysInt.h ISystem.h ISysTick.h
    ../../../../base/017/rel_7/core/: stm32f0xx.h stm32f0xx_adc.c stm32f0xx_adc.h stm32f0xx_cec.c stm32f0xx_cec.h stm32f0xx_comp.c stm32f0xx_comp.h stm32f0xx_conf.h stm32f0xx_crc.c stm32f0xx_crc.h stm32f0xx_dac.c stm32f0xx_dac.h stm32f0xx_dbgmcu.c stm32f0xx_dbgmcu.h stm32f0xx_dma.c stm32f0xx_dma.h stm32f0xx_exti.c stm32f0xx_exti.h stm32f0xx_flash.c stm32f0xx_flash.h stm32f0xx_gpio.c stm32f0xx_gpio.h stm32f0xx_i2c.c stm32f0xx_i2c.h stm32f0xx_iwdg.c stm32f0xx_iwdg.h stm32f0xx_misc.c stm32f0xx_misc.h stm32f0xx_pwr.c stm32f0xx_pwr.h stm32f0xx_rcc.c stm32f0xx_rcc.h stm32f0xx_rtc.c stm32f0xx_rtc.h stm32f0xx_spi.c stm32f0xx_spi.h stm32f0xx_syscfg.c stm32f0xx_syscfg.h stm32f0xx_tim.c stm32f0xx_tim.h stm32f0xx_usart.c stm32f0xx_usart.h stm32f0xx_wwdg.c stm32f0xx_wwdg.h SysInt.c SysInt.h SysLibAll.h System.c System.h SysTick.h SysTickTimer.c SysTypes.h
  group 9. (I)SYS/gpio
    ../../../../base/000/rel_9/gpio/: ISysGpio.h ISysPin.h
    ../../../../base/017/rel_7/gpio/: SysGpio.c SysGpio.h SysPin.c SysPin.h
  group 9. (I)SYS/i2c
    ../../../../base/000/rel_9/i2c/: ISysI2c.h ISysI2cMasterInt.h
    ../../../../base/017/rel_7/i2c/: SysI2c.h SysI2cMasterInt.c SysI2cMasterInt.h
  group 9. (I)SYS/sci
    ../../../../base/000/rel_9/sci/: ISysSci.h ISysSciInt.h
    ../../../../base/017/rel_7/sci/: SysSci.h SysSciInt.c SysSciInt.h
  group 9. (I)SYS/timer
    ../../../../base/000/rel_9/timer/: ISysPwm.h ISysTimer.h
    ../../../../base/017/rel_7/timer/: SysPwm.c SysPwm.h SysTimer.c SysTimer.h
  group 9. (I)SYS/version
    ../../../../base/000/rel_9/: ISysVersion.h
    ../../../../base/008/main/: SysVersion.h
  group linker
    ./: linker.icf
